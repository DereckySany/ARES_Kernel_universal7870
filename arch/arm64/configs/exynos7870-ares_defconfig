## arch/arm64/configs/exynos7870-ares_defconfig
```kconfig
#
#
# AresKernel
#
# hotplug
# CONFIG_EXYNOS_CPU_HOTPLUG is not set
# CONFIG_EXYNOS_HOTPLUG_GOVERNOR is not set
```
